# Keil uVision project Project.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: Project +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: D:\Keil_C51v5\C51\INC\Atmel
  group Source Group 1
    ./: main.c AT24C02.c AT24C02.h Delay.c Delay.h I2C.c I2C.h LCD1602.c LCD1602.h
